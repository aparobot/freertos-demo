# Keil uVision project scproj.uvproj, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: smartcar +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\lib\CMSIS\Core\CM3;..\lib\FreeRTOS\include;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\FreeRTOS\portable\ARM\ARM_CM3;..\config;..\hal\inc;..\drivers\inc;..\modules\inc;..\util\inc;..\modules\inc\log;..\lib\eMPL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group cmsis
    ../lib/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../lib/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group stm32lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_i2c.c
  group freertos
    ../lib/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../lib/FreeRTOS/portable/ARM/ARM_CM3/: port.c
    ../lib/FreeRTOS/portable/MemMang/: heap_4.c
  group config
    ../config/: config.h FreeRTOSConfig.h stm32f10x_conf.h
  group init
    ../init/: main.c
  group hal
    ../hal/src/: freeRTOSdebug.c
  group drivers
    ../drivers/src/: led.c
  group modules
    ../modules/src/: system.c
  group util
    ../util/src/: eprintf.c cfassert.c
